options:
  parameters:
    author: arsalan
    generate_options: qt_gui
    id: Tx
    output_language: python
    title: TX_OFDM
  states: {}

blocks:
- name: chan_freq
  id: variable
  parameters:
    value: 2.2e9
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-60,60)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: tx_if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: tx_rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/arsalan/Desktop/FYP/TransmittedFile.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: tx_bb_gain
    freq0: chan_freq
    gain0: tx_rf_gain
    if_gain0: tx_if_gain
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: OFDM Signal Frequency Domain
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Scope Plot
    label2: ''
    name: OFDM Signal Time Domain
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Original File Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
